# Keil uVision project GprsReader.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1754 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x10000000,0x4000) IRAM2(0x2007C000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GprsReader +hex
  AfterMake: fromelf.exe --bin -o  ./Objects/GprsReader.bin  ./Objects/GprsReader.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\src;..\common\inc
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x10000500 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Source Group 1
    ../src/: utility.c uart.c timer.c nrf24l01.c memory.c main.c iap.c delay.c buffer.c ssp.c GPRS.C ServerProtocal.c rtc.c Comprotocol.c
software components: Device:Startup 1.0.0
